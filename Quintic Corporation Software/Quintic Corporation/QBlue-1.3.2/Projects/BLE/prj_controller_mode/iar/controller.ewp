# IAR project controller.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: QN9020 Quintic QN9020
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_CC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\src\app; ..\..\src\fw; ..\..\src\cmsis; ..\..\src\driver; ..\..\src\lib; ..\..\src\qnevb; ..\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: controller.bin
  ILINK.IlinkOutputFile: controller.out
  ILINK.IlinkIcfFile: ..\..\src\link\iar\qn9020_link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group startup
    ../../src/startup/iar/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c timer.c rtc.c
  group lib
    ../../src/lib/iar/: qn9020b2_lib_peripheral.a
  group qnevb
    ../../src/qnevb/: led.c
  group retarget
    ../../src/retarget/: retarget.c
