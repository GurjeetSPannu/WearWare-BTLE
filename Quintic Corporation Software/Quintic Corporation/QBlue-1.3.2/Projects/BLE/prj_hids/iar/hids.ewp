# IAR project hids.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: QN9020 Quintic QN9020
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_CC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\src\fw; ..\..\src\profiles; ..\..\src\profiles\bas\bass; ..\..\src\app; ..\..\src\app\gap; ..\..\src\app\gatt; ..\..\src\app\smp; ..\..\src\app\bass; ..\..\src\cmsis; ..\..\src\driver; ..\..\src\lib; ..\..\src\qnevb; ..\src; ..\..\src\app\diss; ..\..\src\profiles\dis; ..\..\src\profiles\hogp; ..\..\src\profiles\hogp\hogpd; ..\..\src\app\hogpd; ..\..\src\profiles\dis\diss
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hids.bin
  ILINK.IlinkOutputFile: hids.out
  ILINK.IlinkIcfFile: ..\..\src\link\iar\qn9020_link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group startup
    ../../src/startup/iar/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c
  group app
    ../../src/app/: app_util.c app_env.c app_printf.c app_sys.c app_task.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
    ../../src/app/bass/: app_bass_task.c app_bass.c
    ../../src/app/diss/: app_diss.c app_diss_task.c
    ../../src/app/hogpd/: app_hogpd.c app_hogpd_task.c
  group profiles
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/bas/bass/: bass_task.c bass.c
    ../../src/profiles/dis/diss/: diss.c diss_task.c
    ../../src/profiles/hogp/hogpd/: hogpd.c hogpd_task.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c adc.c analog.c wdt.c timer.c rtc.c
  group lib
    ../../src/lib/iar/: qn9020b2_lib_peripheral.a
  group qnevb
    ../../src/qnevb/: led.c button.c
  group retarget
    ../../src/retarget/: retarget.c
