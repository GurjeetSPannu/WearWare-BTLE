# IAR project pasps.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: QN9020 Quintic QN9020
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_CC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\src\fw; ..\..\src\profiles; ..\..\src\profiles\pasp; ..\..\src\profiles\pasp\pasps; ..\..\src\profiles\dis\diss; ..\..\src\app; ..\..\src\app\gap; ..\..\src\app\gatt; ..\..\src\app\pasps; ..\..\src\app\smp; ..\..\src\app\diss; ..\..\src\cmsis; ..\..\src\driver; ..\..\src\lib; ..\..\src\qnevb; ..\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pasps.bin
  ILINK.IlinkOutputFile: pasps.out
  ILINK.IlinkIcfFile: ..\..\src\link\iar\qn9020_link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group startup
    ../../src/startup/iar/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c
  group app
    ../../src/app/: app_util.c app_env.c app_printf.c app_sys.c app_task.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
    ../../src/app/pasps/: app_pasps.c app_pasps_task.c
  group profiles
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/pasp/pasps/: pasps.c pasps_task.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c rtc.c timer.c wdt.c
  group lib
    ../../src/lib/iar/: qn9020b2_lib_peripheral.a
  group qnevb
    ../../src/qnevb/: led.c button.c
  group retarget
    ../../src/retarget/: retarget.c
