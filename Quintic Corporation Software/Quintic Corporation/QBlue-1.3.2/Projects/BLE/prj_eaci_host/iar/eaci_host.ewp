# IAR project eaci_host.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_CC
  ICCARM.CCDiagSuppress: Pa050,Pa082,Pa093
  ICCARM.CCIncludePath2: ..\src; ..\src\cmsis; ..\src\LPC17xx; ..\src\driver; ..\src\config; ..\src\aci; ..\..\src\fw; ..\..\src\cmsis; ..\..\src\driver; ..\..\src\lib; ..\..\src\qnevb; ..\..\src\profiles; ..\..\src\profiles\anp; ..\..\src\profiles\anp\anpc; ..\..\src\profiles\anp\anps; ..\..\src\profiles\bas; ..\..\src\profiles\bas\basc; ..\..\src\profiles\bas\bass; ..\..\src\profiles\blp; ..\..\src\profiles\blp\blpc; ..\..\src\profiles\blp\blps; ..\..\src\profiles\cscp; ..\..\src\profiles\cscp\cscpc; ..\..\src\profiles\cscp\cscps; ..\..\src\profiles\dis; ..\..\src\profiles\dis\disc; ..\..\src\profiles\dis\diss; ..\..\src\profiles\find; ..\..\src\profiles\find\findt; ..\..\src\profiles\find\findl; ..\..\src\profiles\glp; ..\..\src\profiles\glp\glpc; ..\..\src\profiles\glp\glps; ..\..\src\profiles\hrp; ..\..\src\profiles\hrp\hrps; ..\..\src\profiles\hrp\hrpc; ..\..\src\profiles\htp; ..\..\src\profiles\htp\htpc; ..\..\src\profiles\htp\htpt; ..\..\src\profiles\pasp; ..\..\src\profiles\pasp\paspc; ..\..\src\profiles\pasp\pasps; ..\..\src\profiles\prox; ..\..\src\profiles\prox\proxm; ..\..\src\profiles\prox\proxr; ..\..\src\profiles\rscp; ..\..\src\profiles\rscp\rscpc; ..\..\src\profiles\rscp\rscps; ..\..\src\profiles\scpp; ..\..\src\profiles\scpp\scppc; ..\..\src\profiles\scpp\scpps; ..\..\src\profiles\tip; ..\..\src\profiles\tip\tipc; ..\..\src\profiles\tip\tips; ..\src\app; ..\..\src\app\anpc; ..\..\src\app\anps; ..\..\src\app\basc; ..\..\src\app\bass; ..\..\src\app\blpc; ..\..\src\app\blps; ..\..\src\app\cscpc; ..\..\src\app\cscps; ..\..\src\app\disc; ..\..\src\app\diss; ..\..\src\app\findl; ..\..\src\app\findt; ..\..\src\app\glpc; ..\..\src\app\glps; ..\..\src\app\hrpc; ..\..\src\app\hrps; ..\..\src\app\htpc; ..\..\src\app\htpt; ..\..\src\app\paspc; ..\..\src\app\pasps; ..\..\src\app\proxm; ..\..\src\app\proxr; ..\..\src\app\rscpc; ..\..\src\app\rscps; ..\..\src\app\scppc; ..\..\src\app\scpps; ..\..\src\app\tipc; ..\..\src\app\tips
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: eaci_host.bin
  ILINK.IlinkOutputFile: eaci_host.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default    None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group aci
    ../src/aci/: eaci.c eaci_uart.c
  group app
    ../src/app/: app_data.c app_env.c app_generic.c app_menu.c app_msg.c app_sys.c app_util.c
  group drivers
    ../src/driver/: lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_spi.c uart.c
    ../src/LPC17xx/: system_LPC17xx.c
  group main
    ../src/main/: main.c
  group retarget
    ../../src/retarget/: retarget.c
  group startup
    ../src/LPC17xx/startup/: startup_LPC17xx_iar.s
